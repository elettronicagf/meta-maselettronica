FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI:egfgithub = "git://github.com/elettronicagf/mas-home-config.git;protocol=https;branch=${SRC_BRANCH}"
