FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI:egfgithub = "git://github.com/elettronicagf/mas-test-suite.git;protocol=https;branch=${SRCBRANCH}"
